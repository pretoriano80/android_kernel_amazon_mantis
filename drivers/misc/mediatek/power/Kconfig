## drivers/misc/mediatek/power/Kconfig
```kconfig
config MTK_DUMMY_BATTERY
	bool "MediaTek Dummy Battery Support"
	default n
	---help---
	  MediaTek Dummy Battery Driver
```
